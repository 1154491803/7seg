# Keil uVision project 7seg.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92R342M28U SC92Rxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: 7seg
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./lib/: SC92R342_HighSensitive_lib_T1_S_V2.0.0.LIB S_TouchKeyCFG.C
